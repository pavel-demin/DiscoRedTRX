<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>trx</value></param>
<param><key>category</key><value>DiscoRedTRX</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>TRX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_cutoff</value></param>
<param><key>value</key><value>[-5000, 5000]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cwl_cutoff</value></param>
<param><key>value</key><value>[-850, -350]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cwu_cutoff</value></param>
<param><key>value</key><value>[350, 850]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lsb_cutoff</value></param>
<param><key>value</key><value>[-3050, -150]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_corr</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>7250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_mode</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_corr</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>7250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_mode</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usb_cutoff</value></param>
<param><key>value</key><value>[150, 3050]</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>5</value></param>
<param><key>output_index</key><value>rx_mode</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>rx_mode</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_2</value></param>
<param><key>input_index</key><value>int(tx_mode &gt; 1)</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>5</value></param>
<param><key>output_index</key><value>tx_mode</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_3</value></param>
<param><key>input_index</key><value>tx_mode</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>red_pitaya_emb_sink</key>
<param><key>id</key><value>red_pitaya_emb_sink_0</value></param>
<param><key>freq</key><value>tx_freq + tx_corr</value></param>
<param><key>chan</key><value>1</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>ptt</key><value>ptt</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>red_pitaya_emb_source</key>
<param><key>id</key><value>red_pitaya_emb_source_0</value></param>
<param><key>freq</key><value>rx_freq + rx_corr</value></param>
<param><key>chan</key><value>1</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>rx_am</key>
<param><key>id</key><value>rx_am_0</value></param>
<param><key>cutoff</key><value>am_cutoff</value></param>
</block>
<block>
<key>rx_ssb</key>
<param><key>id</key><value>rx_cwl_0</value></param>
<param><key>cutoff</key><value>cwl_cutoff</value></param>
</block>
<block>
<key>rx_ssb</key>
<param><key>id</key><value>rx_cwu_0</value></param>
<param><key>cutoff</key><value>cwu_cutoff</value></param>
</block>
<block>
<key>rx_ssb</key>
<param><key>id</key><value>rx_lsb_0</value></param>
<param><key>cutoff</key><value>lsb_cutoff</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>rx_meter</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>type</key><value>f</value></param>
</block>
<block>
<key>rx_ssb</key>
<param><key>id</key><value>rx_usb_0</value></param>
<param><key>cutoff</key><value>usb_cutoff</value></param>
</block>
<block>
<key>tx_am</key>
<param><key>id</key><value>tx_am_0</value></param>
<param><key>cutoff</key><value>am_cutoff</value></param>
</block>
<block>
<key>tx_ssb</key>
<param><key>id</key><value>tx_lsb_0</value></param>
<param><key>cutoff</key><value>lsb_cutoff</value></param>
</block>
<block>
<key>tx_ssb</key>
<param><key>id</key><value>tx_usb_0</value></param>
<param><key>cutoff</key><value>usb_cutoff</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rx_cwl_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rx_cwu_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rx_lsb_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rx_usb_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rx_am_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>rx_meter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>tx_lsb_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>tx_usb_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>tx_am_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_3</source_block_id><sink_block_id>red_pitaya_emb_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>red_pitaya_emb_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_am_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>rx_cwl_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cwu_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_lsb_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rx_usb_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>tx_am_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>tx_lsb_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>tx_usb_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
